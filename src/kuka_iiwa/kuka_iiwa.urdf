Commit message: Updating Kuka Driver

File: src/kuka_iiwa/kuka_iiwa.urdf (robot description, URDF)
Before this commit: robot kuka_iiwa, 8 links, 7 joints
Links:
- link link6: mass 1 -> 1.2
